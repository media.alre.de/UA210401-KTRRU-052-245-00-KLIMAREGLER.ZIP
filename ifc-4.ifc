Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler für Kühldecken, UP, 24 VAC/VDC, Schalter Aus/Komfort/ECO, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UA210401, Raumtemperaturregler für Kühldecken, UP, 24 VAC/VDC, Schalter Aus/Komfort/ECO
In: Raum
Description: Elektronischer Unterputz-Klimaregler zur Heiz-/Kühlregelung in 2- und 4-Rohr-Leitungssysteme für Hotel-, Wohn- und Geschäftsräume. In Verbindung mit dem entsprechenden Deckelset passend in alle gängigen Schalterprogramme. Passende Deckelset-Nr. JZ-007.xxx .Bis zu 5 Ventilantriebe (24V~, stromlos geschlossen) je Ausgang können angesteuert werden. Mit dem Schalter kann zwischen den Betriebsarten Aus/Komfort/ECO gewählt werden. Besonders geeignet zur Kühldeckenregelung durch die Möglichkeit der Taupunktüberwachung. Um die Trägheit von Regelstrecken mit Kühldecken zu kompensieren, verfügt das Gerät über einen Temperaturfühlereingang zur Aufschaltung eines externen Strahlungsfühlers (optional). Der werkseitig eingestellte "Nullpunkt" von ca. 21 °C kann im Gerät um ±5 K verstellt werden. Mit dem Einstellknopf kann die Solltemperatur im Bereich von ±3 K um den eingestellten Nullpunkt verstellt werden. Als Behördenvariante, bei der der Regler für Unbefugte unerreichbar sein soll, kann der externe Fühler auch als Raumfühler (optional) ausgeführt werden. Mit einem internem Poti kann die Verwendung des internen, des externen oder die Verwendung beider Fühler mit einer einstellbaren Wichtung gewählt werden. Kontakteingänge für ECO-Funktion und AUS (Frostschutz).; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UA210401; ModelLabel: KTRRU-052.245#00; GlobalTradeItemNumber: 4050528058348; ProductURL: https://alre.de/produkt_UA210401
Pset_Specification - NominalLength: 0.071 m; NominalWidth: 0.071 m; NominalDepth: 0.049 m; NetWeight: 0.085
Pset_ALRE_ETIM_Properties - Montageart: Unterputz; Farbe: anthrazit; Breite: 71; Höhe: 71; Tiefe: 49; Anschluss: sonstige; Art der Spannungsversorgung: 24 V AC; Kontaktausführung: Schließer (NO); Messbereich: 13; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Max. Spannung der Kontakte: 24; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 1; Temperatur ablesbar: no; Max. Kontaktbelastung: 1; Differenzwert: 1; Sensor extern: no; Thermische Rückkopplung: ohne; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UA210401.pdf
